class NoteFreq
{
  #define NUM_NOTES 108
  public:
//     C         C#       D       Eb        E        F       F#        G       G#        A       Bb        B
    double freq[NUM_NOTES] =
    {
      16.35,   17.32,   18.35,   19.45,   20.60,   21.83,   23.12,   24.50,   25.96,   27.50,   29.14,   30.87,  
      32.70,   34.65,   36.71,   38.89,   41.20,   43.65,   46.25,   49.00,   51.91,   55.00,   58.27,   61.74,  
      65.41,   69.30,   73.42,   77.78,   82.41,   87.31,   92.50,   98.00,   103.8,   110.0,   116.5,   123.5,  
      130.8,   138.6,   146.8,   155.6,   164.8,   174.6,   185.0,   196.0,   207.7,   220.0,   233.1,   246.9,  
      261.6,   277.2,   293.7,   311.1,   329.6,   349.2,   370.0,   392.0,   415.3,   440.0,   466.2,   493.9,  
      523.3,   554.4,   587.3,   622.3,   659.3,   698.5,   740.0,   784.0,   830.6,   880.0,   932.3,   987.8,  
      1047.0,  1109.0, 1175.0,  1245.0,  1319.0,  1397.0,  1480.0,  1568.0,  1661.0,  1760.0,  1865.0,  1976.0,  
      2093.0,  2217.0, 2349.0,  2489.0,  2637.0,  2794.0,  2960.0,  3136.0,  3322.0,  3520.0,  3729.0,  3951.0,  
      4186.0,  4435.0, 4699.0,  4978.0,  5274.0,  5588.0,  5920.0,  6272.0,  6645.0,  7040.0,  7459.0,  7902.0
    };

    const int      c4 = 49 - 1;
    const int midi_c4 = 60;
    const int      a4 = 48 + 10 - 1;

    NoteFreq()
    {
      return;
    }

    double note(int n)
    {
      if (n >= NUM_NOTES) return -1.0;
      return this->freq[n];
    }

    double noteMidi(int n)
    {
      int dn = this->midi_c4 - this->c4;
      int nn = n - dn;
      if( nn <      0        ) return -1.0;
      if( nn > (NUM_NOTES-1) ) return -1.0;
      return this->freq[nn];
    }
};
